/*
********************************************************************************************************************
*描述：    	延时函数
*文件名:   	Delay.c
*应用语言: 	KEIL C51
*版本 :   	V1.0
*作者：   	
********************************************************************************************************************
*/
#define	_DELAY_GLOBAL_

/*
********************************************************************************************************************
* 						导入头文件
********************************************************************************************************************
*/
#include "Delay.H"
#include <INTRINS.H>


/*
************************************************************************************************************************
**函数原型:  	void Delay1us(void)
**参数说明:  	无
**返回值:    	无
**说明:			该函数用于延时1微秒           				   
************************************************************************************************************************
*/
void Delay1us()		//@11.0592MHz
{
	unsigned char i;

	_nop_();
	_nop_();
	i = 1;
	while (--i);
}


/*
************************************************************************************************************************
**函数原型:  	void Delay10us(void)      
**参数说明:  	无
**返回值:    	无
**说明:			该函数用于延时10微秒           				   
************************************************************************************************************************
*/
void Delay10us()		//@11.0592MHz
{
	unsigned char i;

	i = 35;
	while (--i);
}


/*
************************************************************************************************************************
**函数原型:  	void Delay1ms(uint number)           
**参数说明:  	无
**返回值:    	无
**说明:			该函数用于延时1毫秒           				   
************************************************************************************************************************
*/
void Delay1ms()		//@11.0592MHz
{
	unsigned char i, j;

	i = 15;
	j = 90;
	do
	{
		while (--j);
	} while (--i);
}


/*
************************************************************************************************************************
**函数原型:  	void DelayMs(uint number)           
**参数说明:  	number :所要延时的毫秒数
**返回值:    	无
**说明:			该函数用于延时X毫秒           				   
************************************************************************************************************************
*/
void DelayMs(unsigned int number) 
{
	while(number--)
		Delay1ms();
}

