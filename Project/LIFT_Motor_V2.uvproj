# Keil uVision project LIFT_Motor_V2.uvproj, settings and files
target ANE (MCS-51)
  device: STC8H3K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0BFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: LIFT_Motor_V2_001 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Source
  group Startup
    ./: STARTUP.A51
  group Source Files
    ../Source/: main.c Public.C MotorDirver.C KeyApp.C SerialApp.C I2C_AT24CxxApp.c Led.C
  group Driver
    ../Source/: Delay.C TimeBase.C IIC.C AT24C01_02.C KeyFunc.C STC8H_PWM.C UartFunc.C ADC.C
